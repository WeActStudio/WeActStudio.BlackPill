# Keil uVision project proj.uvprojx, settings and files
target AT32F4xx (6160000::V6.16::ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.9
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arduino_ +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: ARDUINO=111,AT32F403AVGT7,USE_STDPERIPH_DRIVER
  c misc: -fgnu
  c include: ..\Config;..\Core;..\At32Libraries\drivers\src;..\At32Libraries\drivers\inc;..\At32Libraries\cmsis\cm4\device_support;..\At32Libraries\cmsis\cm4\device_support\startup\mdk;..\Application;..\ArduinoAPI;..\Libraries\Servo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Application
    ../Application/: main.cpp
  group libraries/Servo
    ../libraries/Servo/: Servo.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c adc.c delay.c exti.c extend_SRAM.c gpio.c pwm.c rtc.c timer.c HardwareSerial.cpp SPI.cpp Tone.cpp at32f403a_407_clock.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Config
    ../Config/: mcu_config.h
  group At32Libraries/drivers
    ../At32Libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group At32Libraries/cmsis
    ../At32Libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../At32Libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group README
    ../: README.md
software components: CMSIS:CORE 5.6.0
